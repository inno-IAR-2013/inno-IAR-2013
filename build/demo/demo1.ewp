# IAR project demo1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: demo1.hex
  ILINK.IlinkOutputFile: demo1.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
configuration Flash (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  ICCARM.CCDefines: IAR; DEBUG; TWR_K60N512
  ICCARM.CCIncludePath2: ..\..\src\common; ..\..\src\cpu; ..\..\src\cpu\headers; ..\..\src\app; ..\..\src\drivers; ..\..\src\drivers\accl; ..\..\src\drivers\adc; ..\..\src\drivers\AT24C02; ..\..\src\drivers\exti; ..\..\src\drivers\delay; ..\..\src\drivers\FTM; ..\..\src\drivers\flash; ..\..\src\drivers\gpio; ..\..\src\drivers\i2c; ..\..\src\drivers\linearccd; ..\..\src\drivers\LED; ..\..\src\drivers\lptmr; ..\..\src\drivers\mcg; ..\..\src\drivers\PIT; ..\..\src\drivers\pmc; ..\..\src\drivers\rtc; ..\..\src\drivers\uart; ..\..\src\drivers\wdog; ..\..\src\drivers\kalman; ..\..\src\platforms
  OBJCOPY.OOCOutputFile: inno.hex
  ILINK.IlinkIcfFile: ..\config files\256KB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group app
    ../../src/app/: common.h include.h isr.c isr.h main.c
  group common
    ../../src/common/: alloc.c assert.c assert.h common.h io.c io.h memtest.c memtest.h printf.c queue.c queue.h startup.c startup.h stdlib.c stdlib.h uif.c uif.h
  group cpu
    ../../src/cpu/: arm_cm4.c arm_cm4.h crt0.s dma_channels.h start.c start.h sysinit.c sysinit.h vectors.c vectors.h
    ../../src/drivers/PIT/: PIT.c PIT.h
  group drivers
    ../../src/drivers/accl/: accl.c accl.h
    ../../src/drivers/adc/: adc.c adc.h adc_cfg.h
    ../../src/drivers/delay/: delay.c
    ../../src/drivers/exti/: exti.c
    ../../src/drivers/mcg/: Fire_kinetis_MCG_CFG.h mcg.c mcg.h mcg_cfg.h
    ../../src/drivers/Flash/: flash.c flash.h
    ../../src/drivers/FTM/: FTM.c FTM.h
    ../../src/drivers/: fuzzy.c fuzzy.h
    ../../src/drivers/gpio/: gpio.c gpio.h gpio_cfg.h
    ../../src/drivers/i2c/: i2c.c i2c.h i2c_cfg.h
    ../../src/drivers/kalman/: kalman.c kalman.h
    ../../src/drivers/LED/: LED.C
    ../../src/drivers/linearccd/: linearccd.c linearccd.h
    ../../src/drivers/lptmr/: lptmr.c lptmr.h
    ../../src/drivers/uart/: uart.c uart.h
    ../../src/drivers/wdog/: wdog.c wdog.h
